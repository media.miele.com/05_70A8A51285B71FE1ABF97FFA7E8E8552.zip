Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 863afb59-a0a9-43d8-970c-687e08e7fac1, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T23:05:13+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11111590_CH_M2234SC_BRWS:24223410_CH_11111590_M2234SC_BRWS, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 372 mm; Depth: 310 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 24223410_CH_11111590_M2234SC_BRWS; sets with these values: 2

# IfcDistributionPort, Port_353526_1
Description: Flow; FlowDirection: SOURCEANDSINK
